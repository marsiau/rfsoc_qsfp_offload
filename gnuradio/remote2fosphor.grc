options:
  parameters:
    author: Marsiau
    generate_options: qt_gui
    id: udp2fosphor
    output_language: python
  states: {}

blocks:
- name: center_F
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab@0:(0,2)
    label: 'Center frequency (MHz):'
    start: '-4195.2*1e6'
    step: '1.0'
    stop: 4195.2*1e6
    value: '800.0'
    widget: counter
  states: {}
- name: center_f
  id: variable
  parameters:
    value: center_F*1e6
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab@0:(0,1)
    label: Sample rate
    label0: d = 2, fs = 2457.6e6
    label1: d = 4, fs =  1228.8e6
    label2: d = 8, fs = 614.4e6
    label3: d = 16, fs = 307.2e6
    num_opts: '4'
    option0: 2457.6e6
    option1: 1228.8e6
    option2: 614.4e6
    option3: 307.2e6
    type: real
    value: 2457.6e6
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center_f
    freq_span: samp_rate
    gui_hint: qtgui_tab@0:(1,0,1,4)
    wintype: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    label0: gr-fosphor
    label1: waterfall
    num_tabs: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_f
    fftsize: '4096'
    gui_hint: qtgui_tab@1
    type: complex
    wintype: window.WIN_HAMMING
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_probe_rate_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [fosphor_qt_sink_c_0, freq, blocks_message_debug_0, print]
- [network_udp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

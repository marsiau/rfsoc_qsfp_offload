options:
  parameters:
    author: Marsiau
    generate_options: qt_gui
    id: udp2fosphor
    output_language: python
  states: {}

blocks:
- name: center_F
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab@0:(0,2)
    label: 'Center frequency (MHz):'
    start: '-4195.2*1e6'
    step: '1.0'
    stop: 4195.2*1e6
    value: '800.0'
    widget: counter
  states: {}
- name: center_f
  id: variable
  parameters:
    value: center_F*1e6
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"Insert your own IP"'
  states: {state: disabled}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab@0:(0,1)
    label: Sample rate
    label0: d = 2, fs = 2457.6e6
    label1: d = 4, fs =  1228.8e6
    label2: d = 8, fs = 614.4e6
    label3: d = 16, fs = 307.2e6
    num_opts: '4'
    option0: 2457.6e6
    option1: 1228.8e6
    option2: 614.4e6
    option3: 307.2e6
    type: real
    value: 2457.6e6
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center_f
    freq_span: samp_rate
    gui_hint: qtgui_tab@0:(1,0,1,4)
    wintype: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
  states: {}
- name: qtgui_graphicitem_0
  id: qtgui_graphicitem
  parameters:
    file: ../assets/rfsoc-pynq.png
    fixedsize: 'True'
    gui_hint: qtgui_tab@0:(0,0)
    height: '1'
    scaleImage: 'True'
    width: '1'
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    label0: gr-fosphor
    label1: waterfall
    num_tabs: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_f
    fftsize: '4096'
    gui_hint: qtgui_tab@1
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: ip_address
    callback: set_decimation
    port: '8080'
    variable: samp_rate
  states: {state: disabled}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: ip_address
    callback: set_fc
    port: '8080'
    variable: center_F
  states: {state: disabled}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_probe_rate_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [fosphor_qt_sink_c_0, freq, blocks_message_debug_0, print]
- [network_udp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

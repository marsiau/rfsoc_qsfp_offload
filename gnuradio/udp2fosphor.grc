options:
  parameters:
    author: Marsiau
    generate_options: qt_gui
    id: udp2fosphor
    output_language: python
  states: {}

blocks:
- name: Fc_Hz
  id: variable
  parameters:
    value: Fc_MHz*1e6
  states: {}
- name: Fc_MHz
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab@0:(0,2)
    label: 'Center frequency (MHz):'
    start: '-4195.2*1e6'
    step: '1.0'
    stop: 4195.2*1e6
    value: '800.0'
    widget: counter
  states: {}
- name: Fs
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab@0:(0,1)
    label: Fs
    label0: d = 2, fs = 2457.6e6
    label1: d = 4, fs =  1228.8e6
    label2: d = 8, fs = 614.4e6
    label3: d = 16, fs = 307.2e6
    num_opts: '4'
    option0: 2457.6e6
    option1: 1228.8e6
    option2: 614.4e6
    option3: 307.2e6
    type: real
    value: 2457.6e6
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"10.42.0.231"'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: 8192//2
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: qsfp_offload
    function_args: Fc_Hz
    function_name: set_fc
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_0_0
  id: variable_function_probe
  parameters:
    block_id: qsfp_offload
    function_args: Fs
    function_name: set_decimation
    poll_rate: '10'
    value: '0'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: Fc_Hz
    freq_span: Fs
    gui_hint: qtgui_tab@0:(1,0,1,4)
    wintype: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: packet_size
    port: '60133'
    src_zeros: 'False'
    type: short
  states: {}
- name: qsfp_offload
  id: epy_module
  parameters:
    source_code: |
      from pynq import PL
      from functools import partial
      from rfsoc_qsfp_offload.overlay import Overlay
      import time

      PL.reset()
      time.sleep(1)
      olf = "/home/msphd/Projects/ms-qsfp-remote/rfsoc_qsfp_offload/bitstream/offloadbd.xsa"
      ol = Overlay(olf, ignore_version=True)

      ol.cmac.mmio.write(0x107C, 0x3) # RSFEC_CONFIG_ENABLE
      ol.cmac.mmio.write(0x1000, 0x7) # RSFEC_CONFIG_INDICATION_CORRECTION
      time.sleep(1)
      ol.cmac.start()
      board_ip = '192.168.4.99'
      ol.netlayer.set_ip_address(board_ip, debug=True)
      client_ip = '192.168.4.1'
      ol.netlayer.sockets[0] = (client_ip, 60133, 60133, True)
      ol.netlayer.populate_socket_table()

      ol.source_select(1) # 0 - DMA | 1 - RF-ADC
      time.sleep(1)
      ADC_TILE = 2       # ADC Tile 226
      ADC_BLOCK = 0       # ADC Block 0
      ADC_SAMPLE_FREQUENCY = 4915.2  # MSps
      ADC_PLL_FREQUENCY    = 491.52   # MHz
      ADC_FC = -800 # Centering around middle of sample rate

      ol.initialise_adc(tile=ADC_TILE,
                        block=ADC_BLOCK,
                        pll_freq=ADC_PLL_FREQUENCY,
                        fs=ADC_SAMPLE_FREQUENCY,
                        fc=ADC_FC)

      DAC_TILE = 0       # DAC Tile 228
      DAC_BLOCK = 0       # DAC Block 0
      DAC_SAMPLE_FREQUENCY = 4915.2  # MSps
      DAC_PLL_FREQUENCY = 491.52   # MHz
      DAC_FC = 0.0

      ol.initialise_dac(tile=DAC_TILE,
                        block=DAC_BLOCK,
                        pll_freq=DAC_PLL_FREQUENCY,
                        fs=DAC_SAMPLE_FREQUENCY,
                        fc=DAC_FC)

      ol.packet_generator.packetsize = 128 # 128 * 64 bytes = 8192 bytes to be sent
      ol.packet_generator.enable()



      set_fc = partial(ol.set_fc, ADC_TILE, ADC_BLOCK)
      set_fc.__name__="set_fc"
      set_decimation = partial(ol.set_decimation, ADC_TILE, ADC_BLOCK)
      set_decimation.__name__="set_decimation"

      #server = ServerThread(set_fc, set_decimation)
      #server.start()
  states: {}
- name: qtgui_tab
  id: qtgui_tab_widget
  parameters:
    label0: gr-fosphor
    label1: waterfall
    num_tabs: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Fs
    fc: Fc_Hz
    fftsize: '4096'
    gui_hint: qtgui_tab@1
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      qsfp_offload.set_fc(Fc_Hz)
      qsfp_offload.set_decimation(Fs)
    section: main_after_start
  states: {state: disabled}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: ip_address
    callback: set_decimation
    port: '8080'
    variable: samp_rate
  states: {state: disabled}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: ip_address
    callback: set_fc
    port: '8080'
    variable: center_F
  states: {state: disabled}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_probe_rate_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [fosphor_qt_sink_c_0, freq, blocks_message_debug_0, print]
- [network_udp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
